# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target F101_CMSIS_FREE_RTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SHARE +hex
  AfterMake: D:\SoftwareCatalog\keil5\ARM\ARMCC\bin\fromelf.exe ..\..\Output\SHARE.axf --bin --output .\SHARE.bin
  c flags: Optim=3 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\CMSIS_FREE_RTOS;..\..\app_psdk_test;..\..\app_user;..\..\drv_bsp;..\..\mid_psdk_arch;..\..\mid_psdk_core\inc;..\..\mid_psdk_upper\inc;..\..\my_bsp;..\..\my_task;..\..\FATFS;..\..\FATFS\option;..\..\my_cocolib
  library: MicroLIB
  memory RVCT4: ROM 0x8035000 size 0x45000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group app_user
    ../../app_user/: application.c main.c stm32f10x_it.c app_config.h app_infor.h application.h FreeRTOSConfig.h main.h myinclude.h stm32f10x_conf.h stm32f10x_it.h
  group app_psdk_test
    ../../app_psdk_test/: test_app_func.c test_msg_push.c test_payload_cam_emu.c test_payload_gimbal_emu.c test_osdk_func.c test_positioning.c
  group drv/bsp
    ../../drv_bsp/: dji_typedef.h sys.c sys.h os_util.h pps.c pps.h hotshoe.c hotshoe.h
  group my_bsp
    ../../my_bsp/: bsp.c bsp.h
  group my_task
    ../../my_task/: cam_task.c cam_task.h key_task.c key_task.h oled_task.c oled_task.h rgb_task.c rgb_task.h runinit_task.c runinit_task.h trigger_task.c trigger_task.h u2rece_task.c u2rece_task.h u2send_task.c u2send_task.h fan_task.c fan_task.h app_updata_task.c app_updata_task.h temp_task.c
  group my_cocolib
    ../../my_cocolib/: COCO_LIB.H cocoguojia_gpio.h cocoguojia_24c02.c cocoguojia_24c02.h cocoguojia_ds18b20.c cocoguojia_ds18b20.h cocoguojia_init.c cocoguojia_init.h cocoguojia_oled.c cocoguojia_oled.h cocoguojia_oledfont.h cocoguojia_rgbled.c cocoguojia_rgbled.h cocoguojia_tim1pwm.c cocoguojia_tim1pwm.h cocoguojia_usart.c cocoguojia_usart.h cocoguojia_usart_ringbuffer.c cocoguojia_usart_ringbuffer.h cocoguojia_sdcard.c cocoguojia_sdcard.h cocoguojia_sdio.c cocoguojia_sdio.h
  group mid/psdk/upper
    ../../mid_psdk_upper/src/: psdk_upper.c psdk_app_func.c psdk_msg_subcribe.c psdk_payload_camera.c psdk_payload_gimbal.c psdk_osdk_func.c psdk_positioning.c
  group mid/psdk/core
    ../../mid_psdk_core/src/: psdk_aes.c psdk_crc.c psdk_md5.c psdk_proto.c psdk_debug.c psdk_proto_parse.c
  group mid/psdk/arch
    ../../mid_psdk_arch/: psdk_arch_sys.c
  group CMSIS_FREE_RTOS
    ../../CMSIS_FREE_RTOS/: cmsis_os.c cmsis_os.h
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group CMSIS
    ../../Libraries/CMSIS/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h core_cm3.c core_cm3.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group DOC
    ../../Doc/: readme.txt
  group FATFS
    ../../FATFS/: diskio.c ff.c diskio.h ff.h ffconf.h integer.h
    ../../FATFS/option/: cc936.c

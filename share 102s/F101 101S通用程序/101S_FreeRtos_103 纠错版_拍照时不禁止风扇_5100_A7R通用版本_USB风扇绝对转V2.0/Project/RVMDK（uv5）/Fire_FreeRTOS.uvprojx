# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target F101_FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=3 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\MYBSP;..\..\MYTASK;..\..\COCOLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_conf.h FreeRTOSConfig.h myinclude.h main.c main.h stm32f10x_it.c stm32f10x_it.h
  group BSP
    ../../MYBSP/: bsp.c bsp.h hotshoe.c
  group MYTASK
    ../../MYTASK/: cam_task.c cam_task.h key_task.c key_task.h oled_task.c oled_task.h rgb_task.c rgb_task.h runinit_task.c runinit_task.h trigger_task.c trigger_task.h Cam_status_task.c temp_task.c
  group COCOLIB
    ../../COCOLIB/: cocoguojia_init.c cocoguojia_init.h cocoguojia_24c02.c cocoguojia_24c02.h cocoguojia_gpio.h cocoguojia_oled.c cocoguojia_oled.h cocoguojia_oledfont.h cocoguojia_rgbled.c cocoguojia_rgbled.h cocoguojia_tim1pwm.c cocoguojia_tim1pwm.h cocoguojia_time5catch.c cocoguojia_time5catch.h cocoguojia_ds18b20.c cocoguojia_ds18b20.h cocoguojia_usart.c cocoguojia_usart.h
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group DOC
    ../../Doc/: readme.txt
